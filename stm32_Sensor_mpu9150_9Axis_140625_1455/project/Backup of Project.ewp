# IAR project Backup of Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pe549, Pa082
  ICCARM.CCIncludePath2: ..\inc; ..\Sensor9Axis; ..\PCA9555_GPIO_Ext; ..\OLED; ..\SRAM; ..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS\Device\ST\STM32F10x\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group Libraries/CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_md.s
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group Libraries/StdPeriph
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Libraries/USB-FS-Device
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Sensor9Axis
    ../Sensor9Axis/: I2Cdev.cpp MPU6050.cpp test_sensor9axis.cpp
  group src
    ../src/: board_detect.c debug.c hw_config.c I2CRoutines.c key.c led.c main.c seven_segment.c stm32f10x_it.c uart_queue.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
