# IAR project WYsteps_nRF.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: WYsteps_nRF.hex
  ILINK.IlinkOutputFile: WYsteps_nRF.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group library/CMSIS
    ../library/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ../library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group library/STM32F10x_StdPeriph_Driver
    ../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group src
    ../src/: debug.c debug.h delay.c delay.h Global_variable.c Global_variable.h hw_config.c hw_config.h main.c mydefs.h nRF24L01.c nRF24L01.h PWM_Interface.c PWM_Interface.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
